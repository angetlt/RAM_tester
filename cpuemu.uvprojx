# Keil uVision project cpuemu.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cpuemu +hex
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\firmware;..\firmware;..\firmware;..\RAM_tester
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ./: main.c driver_flash.c init_stm32f103.c core_cm3.c gpio_stm32f1.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
